# Keil uVision project lesson.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-declaration-after-statement
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: main.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32C031C6Tx/STCubeGenerated/Src/: main.c stm32c0xx_it.c
    ./RTE/Device/STM32C031C6Tx/STCubeGenerated/Inc/: stm32c0xx_it.h
software components: CMSIS:CORE 6.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.0.0, Device:STM32Cube HAL:Cortex 1.0.0, Device:STM32Cube HAL:EXTI 1.0.0, Device:STM32Cube HAL:Flash 1.0.0, Device:STM32Cube HAL:GPIO 1.0.0, Device:STM32Cube HAL:PWR 1.0.0, Device:STM32Cube HAL:RCC 1.0.0, Device:Startup 1.0.0
